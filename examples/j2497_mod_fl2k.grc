<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>j2497_mod</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>7777777</value></param>
</block>
<block>
<key>J2497_encoder</key>
<param><key>id</key><value>J2497_encoder_0</value></param>
<param><key>data</key><value>"00"</value></param>
<param><key>filepath_data</key><value>/home/user1/FISSURE/Custom_Blocks/maint-3.7/gr-j2497/examples/chirp_test_8MSps.iq</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>mid</key><value>"0A"</value></param>
<param><key>filepath_preamble</key><value>/home/user1/FISSURE/Custom_Blocks/maint-3.7/gr-j2497/examples/chirp_test_8MSps.iq</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>127</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tcp_server_sink</key>
<param><key>id</key><value>blocks_tcp_server_sink_0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>31337</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>noblock</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>run `fl2k_tcp -a &lt;this IP&gt; -s 7777777 -p 31337 -b 8`</value></param>
</block>
<connection><source_block_id>J2497_encoder_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_tcp_server_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
